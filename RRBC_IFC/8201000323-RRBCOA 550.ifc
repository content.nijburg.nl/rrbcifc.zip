Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: ee58df14-0892-46dd-90a7-e70538a9e90b, NumberOfSaves: 30]
File name: Project Number
Time: 2024-01-17T13:57:13+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_1652762_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_swirl diffuser rrbc LT_sacs:550, NLRS_57_AIR_UN_swirl diffuser rrbc LT_sacs:550:1652762
In: Default
Type - Description: Round flanged Swirl return grill, Type RRBC; PredefinedType: DIFFUSER; Material: RAL9010
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_swirl diffuser rrbc LT_sacs; SACS_Base_Index: 4
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - t: 1 mm
Type - General - Lookup_Grill_Factors: Grill_Selection_Factors; SACS_Article_Data: RRBC_Data; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 31-03-2022; SACS_Revision_Number: 3.19.01
Type - Identity Data - Assembly Code: 57.00; Cost: 0; Description: Round flanged Swirl return grill, Type RRBC; Manufacturer: Solid Air Climate Solutions; Model: RRBC; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 31-03-2022; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.01; NLRS_C_description: Round flanged Swirl return grill, Type RRBC; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Name: 550; URL: https://solid-air.nl/producten/solid-air-plafondroosters-rtbc-rrbc/
Type - Mechanical - Flow - Max Flow: 250 dm3/s; Min Flow: 80 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 550; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_swirl diffuser rrbc LT_sacs; Family and Type: NLRS_57_AIR_UN_swirl diffuser rrbc LT_sacs: 550; Type: 550; Type Id: 1652286
Model Properties - SACS_Color_Ral: yes; SACS_Connector_Top: yes; SACS_Lined_Plenum: no; SACS_Option_1: RRBC; SACS_Option_2: OA; SACS_Oval_Connector: no; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - NLRS_M_c01_diameter: 250 mm; SACS_Plenum_Height: 1 mm; Size: 250ø; Volume: 0.000832861 m3
Identity Data - Mark: 7125; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: RRBCOA 550; SACS_Article_Code: 8201000323; SACS_Gross_Cost: 197; SACS_Price_Date: 01-02-2022
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Color: RAL9010; SACS_Lining_Thickness: 0 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0
Phasing - Phase Created: New Construction
Visibility - SACS_Show_Arrows: yes; SACS_Warning_Disable: no
